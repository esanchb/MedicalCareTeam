# IAR project MED-SPO2.ewp, settings and files
configuration Debug RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK53DN512Zxxx10 Freescale MK53DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class; ..\..\..\..\app\cdc\iar_ew\kinetis\MED_KIOSK_FILES\APP; ..\..\..\..\app\cdc\iar_ew\kinetis\MED_KIOSK_FILES\APP\Med-EKG; ..\..\..\..\app\cdc\iar_ew\kinetis\MED_KIOSK_FILES\LL_DRIVERS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MED-SPO2.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\MK53N512CMD100_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config\MK53N512CMD100_Flash.icf
  group (top)
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
    ../../: usb_descriptor.c virtual_com.c
  group class
    ../../../../source/class/: usb_cdc.c usb_cdc_pstn.c
    ../../../../source/common/: usb_class.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group source/application
    MED_KIOSK_FILES/APP/Med-EKG/: AverageFilter.c AverageFilter.h PublicTypes.h SerialCommands.h
    MED_KIOSK_FILES/APP/: dsp.h dsp.s Kinetis_FIR.c Kinetis_FIR.h Kinetis_FTM.c Kinetis_FTM.h Main_App.c Main_App.h opamp_detect.c opamp_detect.h PulseOximeter.c PulseOximeter.h SwTimer.c SwTimer.h SystemConfig.h TWR_K50_UI.h
  group source/drivers
    MED_KIOSK_FILES/LL_DRIVERS/: ADC.c ADC.h DAC.c DAC.h IICV1Driver.c IICV1Driver.h IICV1HAL_K50.h OPAMP.c OPAMP.h
    MED_KIOSK_FILES/APP/: lptmr.c lptmr.h
  group prm
    config/: MK40N512VMD100_Flash.icf MK40N512VMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
